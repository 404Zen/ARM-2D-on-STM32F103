# Keil uVision project ARM-2D on STM32F103.uvprojx, settings and files
target ARM-2D on STM32F103 (6160000::V6.16::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: ARM-2D on STM32F103 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE,FK103M5
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\BSP;..\LCD;..\Arm-2D\Library\Include;..\Arm-2D\Helper\Include;..\APP;..\platform;..\platform\Common
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group BSP
    ../BSP/: delay.c led.c
  group LCD
    ../LCD/: DEV_Config.c LCD_1in3.c
  group ARM-2D
    ../Arm-2D/Library/Include/: __arm_2d_impl.h __arm_2d_math.h __arm_2d_math_helium.h __arm_2d_paving.h __arm_2d_paving_helium.h __arm_2d_utils_helium.h arm_2d.h arm_2d_alpha_blending.h arm_2d_conversion.h arm_2d_draw.h arm_2d_features.h arm_2d_op.h arm_2d_rotation.h arm_2d_tile.h arm_2d_types.h arm_2d_utils.h
    ../Arm-2D/Library/Source/: __arm_2d_alpha_blending.inc __arm_2d_alpha_blending_wrapper.inc __arm_2d_alpha_mask.inc __arm_2d_alpha_mask_helium.inc __arm_2d_copy.inc __arm_2d_copy_helium.inc __arm_2d_core.c __arm_2d_draw_pattern.inc __arm_2d_draw_pattern_helium.inc __arm_2d_fill_colour.inc __arm_2d_fill_colour_helium.inc __arm_2d_meta_copy_and_fill.inc __arm_2d_meta_copy_with_masks.inc __arm_2d_meta_copy_with_masks_helium.inc __arm_2d_rotate.inc __arm_2d_rotate_helium.inc __arm_2d_tile.c arm_2d.c arm_2d_alpha_blending.c arm_2d_async.c arm_2d_conversion.c arm_2d_draw.c arm_2d_helium.c arm_2d_rotation.c
  group ARM-2D-Helper
    ../Arm-2D/Helper/Include/: arm_2d_helper.h arm_2d_helper_pfb.h
    ../Arm-2D/Helper/Source/: arm_2d_helper_pfb.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
